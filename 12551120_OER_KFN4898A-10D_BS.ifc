Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-22T15:47:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 22 15:47:18 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\96a95875-f9cb-46de-ba61-43f79637f9b6\15dd99e3-67e0-4f23-93c2-9326b656ee46\ifc * Database version: 5507 * Database creation date: Mon Jan 22 15:47:17 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 22 15:47:17 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 22 15:47:17 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12551120_OER_KFN4898A-10D_BS:38489802_OER_12551120_KFN4898A-10D_BS, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 38489802_OER_12551120_KFN4898A-10D_BS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 38489802_OER_12551120_KFN4898A-10D_BS
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 2010 mm; Depth: 675 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_Cast, z_Miele_Design_BST, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_355623
Description: Flow; FlowDirection: SOURCEANDSINK
